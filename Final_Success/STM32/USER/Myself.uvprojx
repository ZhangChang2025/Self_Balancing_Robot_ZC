# Keil uVision project Myself.uvprojx, settings and files
target bluetooth_control (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bluetooth_control +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CMSIS;..\FWLib\inc;..\BSP;..\BSP\Delay;..\BSP\Enconder;..\BSP\IIC_Software;..\BSP\Motor;..\BSP\MPU6050;..\BSP\MPU6050\DMP;..\BSP\Usart1;..\BSP\INT_Sever;..\BSP\Battery;..\APP;..\APP\filter;..\APP\KF;..\APP\PID;..\BSP\OLED;..\BSP\Key;..\BSP\Beep;..\BSP\LED;..\BSP\Timer;..\BSP\Bluetooth;..\BSP\Ultrasonic;..\BSP\51_USART
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER
    ./: main.c stm32f10x_it.c AllHeader.h myenum.h switch_function.h
  group CMSIS
    ../CMSIS/: system_stm32f10x.c core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group BSP
    ../BSP/Delay/: delay.c
    ../BSP/Enconder/: encoder.c
    ../BSP/IIC_Software/: IOI2C.c
    ../BSP/Motor/: motor.c
    ../BSP/MPU6050/: mpu6050.c
    ../BSP/Usart1/: usart.c bsp_usart2.c
    ../BSP/: bsp.c
    ../BSP/INT_Sever/: intsever.c
    ../BSP/Battery/: bsp_battery.c
    ../BSP/OLED/: bsp_oled_i2c.c bsp_oled.c oled_fonts.c
    ../BSP/Beep/: bsp_beep.c
    ../BSP/LED/: bsp_LED.c
    ../BSP/Timer/: bsp_timer.c
    ../BSP/Key/: bsp_key.c
    ../BSP/Bluetooth/: bsp_bluetooth.c
    ../BSP/Ultrasonic/: bsp_ultrasonic.c
    ../BSP/51_USART/: bsp_51_usart.c
  group APP
    ../APP/: app_control.c app_motor.c app_k210.c
    ../APP/PID/: pid_control.c
    ../BSP/Bluetooth/: app_bluetooth.c
  group DMP
    ../BSP/MPU6050/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group algorithm_my
    ../APP/filter/: filter.c
    ../APP/KF/: KF.c
